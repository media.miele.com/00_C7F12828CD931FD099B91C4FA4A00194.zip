Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ba2cab3f-a823-44d6-8fb4-e85e27fcb106, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-18T09:50:03+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12821040_NER_DAE1530_EDST:28E1530S_NER_12821040_DAE1530_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Connection_Modul, z_Miele_Design_GRGR, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 532 mm; Height: 326 mm; Depth: 372 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28E1530S_NER_12821040_DAE1530_EDST; sets with these values: 2
